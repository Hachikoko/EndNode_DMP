# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,MPU9250,EMPL_TARGET_STM32F4,EMPL,USE_DMP,MPL_LOG_NDEBUG=1
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\SYSTEM\SPI;..\SYSTEM\NRF24L01;..\SYSTEM\Timer;..\SYSTEM\IIC;..\HARDWARE\MPU9250;..\HARDWARE\NRF24L01;..\SYSTEM\fliter;..\SYSTEM\link_queue;..\SYSTEM\DMP_MPL_core\driver\eMPL;..\SYSTEM\DMP_MPL_core\driver\include;..\SYSTEM\DMP_MPL_core\driver\stm32L;..\SYSTEM\DMP_MPL_core\eMPL-hal;..\SYSTEM\DMP_MPL_core\mllite;..\SYSTEM\DMP_MPL_core\mpl;..\SYSTEM\GPIO_INT_FOR_MPU;..\SYSTEM\board;..\SYSTEM\Uranus_packet
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/SPI/: SPI.c
    ../SYSTEM/Timer/: Timer.c
    ../SYSTEM/IIC/: IIC.c i2c.c
    ../SYSTEM/link_queue/: link_queue.c
    ../SYSTEM/board/: board_init.c
    ../SYSTEM/GPIO_INT_FOR_MPU/: gpio.c
    ../SYSTEM/usart/: uart.c
    ../SYSTEM/Uranus_packet/: packet1.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/NRF24L01/: NRF24L01.c
  group DMP_MPL
    ../SYSTEM/DMP_MPL_core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../SYSTEM/DMP_MPL_core/driver/stm32L/: log_stm32.c
    ../SYSTEM/DMP_MPL_core/eMPL-hal/: eMPL_outputs.c
    ../SYSTEM/DMP_MPL_core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../SYSTEM/DMP_MPL_core/mpl/: libmpllib.lib
